# IAR project Watch.ewp, settings and files
configuration Devboard (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 280
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DIGITAL; HW_DEVBOARD_V2; DMA; LPM_ENABLED; xTASK_DEBUG; xBLASTER
  ICC430.newCCIncludePaths: ..\..\Common\FreeRTOS\include; ..\..\Common\FreeRTOS\portable\MSP430F5438; ..\..\Common\Hardware; ..\..\Common\Hardware\OSAL\; ..\..\Common\Application; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: LinkerConfiguration.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -C ..\..\Library\Stack2.a; -C ..\..\Library\Stack.r43
configuration Digital (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; DMA; LPM_ENABLED; xTASK_DEBUG; xBLASTER
  ICC430.CCOptStrategy: 1
configuration Analog Devboard (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ANALOG; HW_DEVBOARD_V2; DMA; LPM_ENABLED; TASK_DEBUG; xBLASTER
  ICC430.newCCIncludePaths: ..\..\Common\FreeRTOS\include; ..\..\Common\FreeRTOS\portable\MSP430F5438; ..\..\Common\Hardware; ..\..\Common\Hardware\OSAL; ..\..\Common\Application; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application
configuration Analog (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ANALOG; WATCH; DMA; LPM_ENABLED; xTASK_DEBUG; xBLASTER
  ICC430.newCCIncludePaths: as above
configuration DigitalMin (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; DMA; LPM_ENABLED; xTASK_DEBUG; xBLASTER
  group Application
    ../Application/: Adc.c Background.c Bluetooth.c Bluetooth.h BufferPool.c Buttons.c CommandTask.c DebugUart.c Display.c Fonts.c Fonts.h HuffManEngText.c HuffmanEngText.h Icons.c Icons.h IdlePage.c IdlePage.h IdlePageGameOfLife.h IdlePageMain.c IdlePageMain.h IdlePageQrCode.c IdlePageQrCode.h IdlePageWatchStatus.c IdlePageWatchStatus.h InterruptVectors.c LcdBuffer.c LcdBuffer.h LcdDisplay.c LcdTask.c LinkAlarm.c LinkAlarm.h main.c Menu.c Menu.h MenuApp.c MenuApp.h Menus.c Menus.h MessageQueues.c MusicMenu.c MusicMenu.h OledDisplay.c OledFonts.c OneSecondTimers.c Pedometer.c SerialRam.c Statistics.c Utilities.c Vibration.c
  group Common/Application
    ../../Common/Application/: BufferPool.h DebugUart.h Display.h LcdDisplay.h MessageQueues.h Messages.h OneSecondTimers.h SerialProfile.h Statistics.h Utilities.h
  group Common/FreeRTOS
    ../../Common/FreeRTOS/: croutine.c list.c queue.c tasks.c
  group Common/FreeRTOS/include
    ../../Common/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h TaskTCB.h
  group Common/FreeRTOS/portable/MemMang
    ../../Common/FreeRTOS/portable/MemMang/: heap_2.c
  group Common/FreeRTOS/portable/MSP430F5438A
    ../../Common/FreeRTOS/portable/MSP430F5438/: FreeRTOSConfig.h Lowinit.c port.c portext_s43.asm portmacro.h
  group Common/Hardware
    ../../Common/Hardware/: hal_clock_control.h hal_lpm.h macro.h
  group Common/Hardware/OSAL
    ../../Common/Hardware/OSAL/: MSP430FlashUtil.c NvIds.h OSAL_Nv.c
  group Hardware
    ../Hardware/: hal_accelerometer.c hal_analog_display.c hal_analog_v2_defs.h hal_battery.c hal_board_type.h hal_calibration.c hal_clock_control.c hal_devboard_v2_defs.h hal_digital_v2_defs.h hal_lpm.c hal_miscellaneous.c hal_oled.c hal_rtc.c hal_rtos_timer.c hal_vibe.c OledDriver.c RTCASMFunctions_IAR.s43
  group Hardware/F5xx_F6xx_Core_Lib
    ../Hardware/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
